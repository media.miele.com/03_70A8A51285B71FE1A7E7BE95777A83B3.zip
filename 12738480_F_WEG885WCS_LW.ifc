Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: e3fe69d4-8d91-4ca6-a5fa-696579026455, NumberOfSaves: 1]
File name: 0001
Time: 2026-08-17T09:47:59+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12738480_F_WEG885WCS_LW:11EG8851_F_12738480_WEG885WCS_LW, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_Orange, z_Miele_Design_Glass, z_Miele_Design_OBSW, z_Miele_Design_Alusilver, z_Miele_Design_Powder Coat_Lotus White, z_Miele_Design_Glass Black, z_Miele_Design_Zinc_Steel, z_Miele_Connection_Water_OUT, z_Miele_Connection_Water_IN, z_Miele_Connection_Electric, <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 596 mm; Height: 850 mm; Depth: 636 mm
Classification: E1010610 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 11EG8851_F_12738480_WEG885WCS_LW; sets with these values: 2

# IfcDistributionPort, Port_360247_1
Description: Flow; FlowDirection: SOURCEANDSINK
